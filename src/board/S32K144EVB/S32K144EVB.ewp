# IAR project S32K144EVB.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; GCC_BUILD
  ICCARM.CCIncludePath2: src; ..\..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_S32K_Demo.srec
  ILINK.IlinkOutputFile: LQ_S32K_demo.elf
  ILINK.IlinkIcfFile: src\S32K144_100_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_FLASH (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCIncludePath2: src\user; src\system; D:\software\rtos\ygOS\src\include
  OBJCOPY.OOCOutputFile: LQ_S32K_Demo.hex
  ILINK.IlinkIcfFile: src\linker\S32K144_100_flash.icf
  group S32K
    src/: startup.c startup_S32K144.s system_S32K144.c
  group ygos
    ../../kernel/: core.c idle.c
    ../qemu-vexpress-a9/: main.c
    ../../ipc/: sem.c
    ../../arch/arm/armv7-m/: stack.c switch_iar.s
