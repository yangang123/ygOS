# Keil uVision project ygos.uvprojx, settings and files
target ygos (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: minios
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\src;..\..\src\board\mdk_sim;..\..\app\ygsh;..\..\src\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ../../src/kernel/: core.c idle.c sleep.c switch.c
    ../../src/mm/: malloc.c
    ../../src/ipc/: sem.c
  group board
    ../../src/board/mdk_sim/: systick.c
  group fs
    ../../src/fs/: fs_driver.c fs_mount.c fs_syscall.c
    ../../src/fs/deviceNode/: fs_inode.c
  group driver
    ../../src/driver/: ramlog.c
  group fs/proc
    ../../src/fs/procfs/: fs_proc.c fs_procfs_uptime.c
  group ygsh
    ../../app/ygsh/: cmd_cat.c cmd_echo.c
  group fs/fat
    ../../src/fs/fatfs/: fs_fat32.c fs_utils.c fs_utils_arm.c
  group app
    ../../app/platform/stm32/: fat32_test.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
