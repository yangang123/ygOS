# Keil uVision project project.uvprojx, settings and files
target qxwz_track (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qxwz_fw +hex
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ./BIN/ygOS.bin  ./OBJ/qxwz_fw.axf
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,VECT_TAB_OFFSET=0
  c include: ..\..\src\board\stm32f4_discovery\stm32f4\STM32F4xx_StdPeriph_Driver\inc;..\..\src\board\stm32f4_discovery\stm32f4\CMSIS\DEVICE\ST\STM32F4xx\Include;..\..\src\board\stm32f4_discovery\stm32f4\CMSIS\Include;..\..\src\board\stm32f4_discovery\stm32f40x_v1;..\..\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32_StdPeriph
    ../../src/board/stm32f4_discovery/stm32f4/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../../src/board/stm32f4_discovery/stm32f4/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group src
    ../../src/board/stm32f4_discovery/stm32f40x_v1/: bsp_led.c main.c stm32f4xx_it.c system_stm32f4xx.c timer.c
  group ygOS
    ../../src/kernel/: core.c idle.c sleep.c switch.c
